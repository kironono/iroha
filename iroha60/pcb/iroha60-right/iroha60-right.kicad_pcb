# Repository kironono/iroha

File README.md:

# iroha

The iroha is a split keyboard inspired by the HHKB layout.

## Variation of iroha

- iroha60:
 60% split keyboard.

## Photography

## License

`iroha` is distributed under the terms of the MIT license.

See the [LICENSE](LICENSE) files in this repository for more information.

## KiCad design iroha60/pcb/iroha60-right/iroha60-right.kicad_pcb

File iroha60/pcb/README.md:

```
$ git clone git@github.com:foostan/kbd.git lib/kbd
$ git clone git@github.com:ai03-2725/MX_Alps_Hybrid.git lib/MX_Alps_Hybrid
$ git clone git@github.com:daprice/keyswitches.pretty.git lib/keyswitches.pretty
```

Board: 2 copper layers, 161.9 x 95.2 mm, 72 parts (4 on the bottom side), 52 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34: D; D3_TH_SMD
J1: MJ-4PP-9; MJ-4PP-9_1side
J2: LED; StripLED_1side
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW17, SW18, SW19, SW20, SW21, SW22, SW24, SW25, SW26, SW27, SW28, SW30, SW33, SW35: SW_PUSH; MX-1U-NoLED
SW16, SW32: SW_PUSH; MX-1.5U-NoLED
SW23: SW_PUSH; MX-2.25U-NoLED
SW29: SW_PUSH; MX-1.75U-NoLED
SW31: SW_PUSH; MX-2.25U-ReversedStabilizers-NoLED
SW34: RESET_SW; ResetSW_1side
U1: ProMicro; ProMicro_v2_1side

Connections:
GND: J1.C, J2.1, SW34.2, U1.3, U1.4, U1.23
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: D22.2, SW22.2
unnamed: D23.2, SW23.2
unnamed: D24.2, SW24.2
unnamed: D25.2, SW25.2
unnamed: D26.2, SW26.2
unnamed: D27.2, SW27.2
unnamed: D28.2, SW28.2
unnamed: D29.2, SW29.2
unnamed: D30.2, SW30.2
unnamed: D31.2, SW31.2
unnamed: D32.2, SW32.2
unnamed: D33.2, SW33.2
unnamed: D34.2, SW35.2
VCC: J1.D, J2.3, U1.21
col0: SW1.1, SW9.1, U1.20
col1: SW2.1, SW10.1, SW17.1, SW24.1, SW30.1, U1.19
col2: SW3.1, SW11.1, SW18.1, SW25.1, SW31.1, U1.18
col3: SW4.1, SW12.1, SW19.1, SW26.1, SW32.1, U1.17
col4: SW5.1, SW13.1, SW20.1, SW27.1, SW33.1, U1.16
col5: SW6.1, SW14.1, SW21.1, SW28.1, U1.15
col6: SW7.1, SW15.1, SW22.1, SW29.1, U1.14
col7: SW8.1, SW16.1, SW23.1, SW35.1, U1.13
data: J1.B, U1.2
led: J2.2, U1.1
reset: SW34.1, U1.22
row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, U1.7
row1: D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, U1.8
row2: D17.1, D18.1, D19.1, D20.1, D21.1, D22.1, D23.1, U1.9
row3: D24.1, D25.1, D26.1, D27.1, D28.1, D29.1, D34.1, U1.10
row4: D30.1, D31.1, D32.1, D33.1, U1.11

## KiCad design iroha60/pcb/iroha60.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69: D; D3_TH_SMD
J1, J3, J5, J7: i2c-pin; 1pin_conn
J2, J6: MJ-4PP-9; MJ-4PP-9_1side
J4, J8: LED; StripLED_1side
JP1, JP2, JP3: Jumper
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW9, SW10, SW11, SW12, SW13, SW15, SW16, SW17, SW18, SW19, SW21, SW22, SW23, SW24, SW25, SW26, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW54, SW55, SW56, SW57, SW58, SW59, SW61, SW62, SW63, SW66, SW67, SW68, SW69: SW_PUSH; MX-1U-NoLED
SW8, SW27, SW45, SW65: SW_PUSH; MX-1.5U-NoLED
SW14, SW60: SW_PUSH; MX-1.75U-NoLED
SW20, SW53, SW64: SW_PUSH; MX-2.25U-NoLED
SW28: SW_PUSH; MX-2.75U-NoLED
SW70, SW71: RESET_SW; ResetSW_1side
U1, U2: ProMicro; ProMicro_v3

Connections:
GND: J2.C, J4.1, J6.C, J8.1, SW70.2, SW71.2, U1.3 (GND), U1.4 (GND), U1.23 (GND), U2.3 (GND), U2.4 (GND), U2.23 (GND)
L-col0: SW1.1, U1.20 (F4/A3)
L-col1: SW2.1, SW8.1, SW14.1, SW20.1, U1.19 (F5/A2)
L-col2: SW3.1, SW9.1, SW15.1, SW21.1, U1.18 (F6/A1)
L-col3: SW4.1, SW10.1, SW16.1, SW22.1, U1.17 (F7/A0)
L-col4: SW5.1, SW11.1, SW17.1, SW23.1, SW26.1, U1.16 (B1/15)
L-col5: SW6.1, SW12.1, SW18.1, SW24.1, SW27.1, U1.15 (B3/14)
L-col6: SW7.1, SW13.1, SW19.1, SW25.1, SW28.1, U1.14 (B2/16)
L-data: JP1.1, JP3.2, U1.2 (RX1/D2)
L-led: J4.2, U1.1 (TX0/D3)
L-row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), U1.7 (4/D4)
L-row1: D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), U1.8 (5/C6)
L-row2: D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), U1.9 (6/D7)
L-row3: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), U1.10 (7/E6)
L-row4: D26.1 (K), D27.1 (K), D28.1 (K), U1.11 (8/B4)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
unnamed: D68.2 (A), SW68.2
unnamed: D69.2 (A), SW69.2
unnamed: J1.1, J2.A
unnamed: J2.B, J3.1, JP1.2
unnamed: J5.1, J6.A
unnamed: J6.B, J7.1, JP2.2
R-col0: SW29.1, SW38.1, U2.20 (F4/A3)
R-col1: SW30.1, SW39.1, SW47.1, SW55.1, SW63.1, U2.19 (F5/A2)
R-col2: SW31.1, SW40.1, SW48.1, SW56.1, SW64.1, U2.18 (F6/A1)
R-col3: SW32.1, SW41.1, SW49.1, SW57.1, SW65.1, U2.17 (F7/A0)
R-col4: SW33.1, SW42.1, SW50.1, SW58.1, SW66.1, U2.16 (B1/15)
R-col5: SW34.1, SW43.1, SW51.1, SW59.1, U2.15 (B3/14)
R-col6: SW35.1, SW44.1, SW52.1, SW60.1, SW67.1, U2.14 (B2/16)
R-col7: SW36.1, SW45.1, SW53.1, SW61.1, SW68.1, U2.13 (B6/10)
R-col8: SW37.1, SW46.1, SW54.1, SW62.1, SW69.1, U2.12 (9/B5)
R-data: JP2.1, JP3.1, U2.2 (RX1/D2)
R-led: J8.2, U2.1 (TX0/D3)
R-reset: SW71.1, U2.22 (RST)
R-row0: D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), U2.7 (4/D4)
R-row1: D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), U2.8 (5/C6)
R-row2: D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), U2.9 (6/D7)
R-row3: D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), U2.10 (7/E6)
R-row4: D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), U2.11 (8/B4)
VCC: J2.D, J4.3, J6.D, J8.3, U1.21 (VCC), U2.21 (VCC)
reset: SW70.1, U1.22 (RST)

Board: 2 copper layers, 305.0 x 95.4 mm, 153 parts (8 on the bottom side), 107 nets.

## Commit log

2019-12-21 Added keyboard layout
2019-12-21 init KiCad project
2019-12-21 Added schema
2019-12-22 Updated layout
2019-12-26 left sch
2019-12-26 right sch
2019-12-31 Added README
2019-12-31 PCB Updated
2020-01-06 Removed old files
2020-07-25 Published data rev1
2020-08-12 Published rev1-2020-08-12
2020-08-13 Added plate
2020-08-14 Updated plate
2020-08-23 Improved bottom plate, compatible with smoked acrylic
2020-08-25 Clean
2021-09-01 Added images
